<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\build\k60_demo\k60_demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


